# Keil uVision project Project.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.3
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I2C_TwoBoard_CommunicationSlave_IT_Init +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: PY32F002Ax5,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\PY32F002xx_Start_Kit;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\..\..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f002xx.s
  group Application/User
    ../Src/: main.c py32f0xx_it.c
    ../Inc/: SEGGER_RTT_printf.c SEGGER_RTT.c
  group BSP/py32f002xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F002xx_Start_Kit/: py32f002xx_ll_Start_Kit.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_utils.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_rcc.c py32f0xx_ll_tim.c
    ./../../../../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_adc.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
